inherit packagegroup

SUMMARY = "Bea packagegroup for utility"

PACKAGES = "\
  packagegroup-bea-utility \
"

RDEPENDS:packagegroup-bea-utility = "\
  bc \
  tar \
  screen \
"