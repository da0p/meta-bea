inherit packagegroup

SUMMARY = "Bea packagegroup for test"

PACKAGES = "\
  packagegroup-bea-test \
"

RDEPENDS:packagegroup-bea-test = "\
  simplehello \
  simpleechoserver \
"