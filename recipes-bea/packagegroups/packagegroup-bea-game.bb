inherit packagegroup

SUMMARY = "Bea packgroup for games"

PACKAGES = "\
  packagegroup-bea-game \
"

RDEPENDS:packagegroup-bea-game = "\
  ninvaders \
"